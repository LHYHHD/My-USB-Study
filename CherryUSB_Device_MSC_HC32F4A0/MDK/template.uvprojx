# Keil uVision project template.uvprojx, settings and files
target template_Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F4A0SITB HDSC
  pack: HDSC.HC32F4A0.1.0.8
  cpu: IROM1(0x00000000,0x200000) IROM2(0x03000000,0x1800) IRAM1(0x1FFE0000,0x80000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: template +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: __DEBUG,HC32F4A0,USE_DDL_DRIVER,
  c include: ..\Drivers\bsp;..\Drivers\cmsis\Include;..\Drivers\cmsis\Device\HDSC\hc32f4xx\Include;..\Drivers\hc32_ll_driver\inc;..\Middlewares;..\User;..\Middlewares\CherryUSB\app;..\Middlewares\CherryUSB\class\msc;..\Middlewares\CherryUSB\common;..\Middlewares\CherryUSB\core;..\Middlewares\CherryUSB\port
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1ffe0000 size 0x80000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\config\linker\HC32F4A0xI.sct
  link misc: --keep=*Handler
  group Drivers/cmsis
    ../drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f4a0.c
    ../drivers/cmsis/Device/HDSC/hc32f4xx/Source/ARM/: startup_hc32f4a0.s
  group Drivers/hc32_ll_driver
    ../drivers/hc32_ll_driver/src/: hc32_ll.c hc32_ll_icg.c hc32_ll_clk.c hc32_ll_utility.c hc32_ll_sram.c hc32_ll_efm.c hc32_ll_gpio.c hc32_ll_fcg.c hc32_ll_pwc.c hc32_ll_aos.c hc32_ll_dma.c hc32_ll_interrupts.c hc32_ll_tmr2.c hc32_ll_tmra.c hc32_ll_tmr0.c hc32_ll_adc.c hc32_ll_ots.c hc32_ll_rtc.c hc32f4a0_ll_interrupts_share.c hc32_ll_sdioc.c hc32_ll_usart.c hc32_ll_spi.c
  group Drivers/bsp
    ../Drivers/bsp/: w25qxx.c spi.c rtc.c ots.c uart1.c tmr0.c sd_diskio.c sd.c
  group User
    ../User/: delay_systick.c main.c systemClockConfig.c gpio_bit.h hc32f4xx_conf.h
  group Middlewares/MALLOC
    ../Middlewares/MALLOC/: malloc.c
  group Middlewares/DEBUG
    ../Middlewares/DEBUG/: debug.c
  group Middlewares/FATFS
    ../Middlewares/FATFS/EXFUNS/: exfatfs.c
    ../Middlewares/FATFS/source/: diskio.c ff.c ffunicode.c ffconf.h
  group Middlewares/CherryUSB/app
    ../Middlewares/CherryUSB/app/: msc_storage.c usb_config.h
  group Middlewares/CherryUSB/core
    ../Middlewares/CherryUSB/core/: usbd_core.c usbd_core.h
  group Middlewares/CherryUSB/class/MSC
    ../Middlewares/CherryUSB/class/msc/: usb_msc.h usb_scsi.h usbd_msc.c usbd_msc.h
  group Middlewares/CherryUSB/port
    ../Middlewares/CherryUSB/port/: usb_dc_dwc2.c usb_dwc2_reg.h usb_glue_hc.c
